FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "netfilter.cfg ipset.cfg"
